# ttyS3 is UART5, BMC's serial port
SERIAL_CONSOLES += "115200;ttyS3"
