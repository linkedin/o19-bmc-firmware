
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://i2c.patch \
           "
